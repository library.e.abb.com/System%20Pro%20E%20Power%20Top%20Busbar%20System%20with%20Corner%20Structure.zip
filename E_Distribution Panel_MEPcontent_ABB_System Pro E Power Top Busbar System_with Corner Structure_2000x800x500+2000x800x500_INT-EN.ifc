Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2020-04-02T15:26:49
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Apr 02 15:26:49 2020 * Host: LCOLTOI-RO-DE * Database: C:\Users\lcoltoi\AppData\Local\Temp\{35C17D42-76E1-475B-9F80-ECE4A44B145D}\ifc * Database version: 5507 * Database creation date: Thu Apr 02 15:26:47 2020 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Thu Apr 02 15:26:47 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Apr 02 15:26:47 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, V00
LongName: V00; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Floor Level; Family and Type: Level: Floor Level; Type: Level: Floor Level; Type Id: Level: Floor Level
Identity Data - Type Name: Floor Level; Building Story: yes; Name: V00; Structural: no
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent: standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm

# IfcElectricDistributionBoard: 2000x800x500+2000x800x500, E_Distribution Panel_MEPcontent_ABB_System Pro E Power Top Busbar System_with Corner Structure_INT-EN:2000x800x500+2000x800x500:1304773
In: V00
Type - PredefinedType: DISTRIBUTIONBOARD; Material: Color RGB 215-215-215, Color RGB 028-028-028, Color RGB 040-040-040
Type - Dimensions - Depth: 599 mm; Height: 2113 mm; Width Cabinet 1: 899 mm; Width Cabinet 2: 899 mm
Type - Electrical - App ID: EL_MODELPARTSYSTEM_MC; Compliance with Standard: IEC 61439-1-2; IP protection class: IP30, IP31, IP40, IP41, IP65; Phase: 3; Rated current In: up to 6300A; Rated frequency: 50-60Hz; Rated impulse withstand voltage Uimp: 12kV; Rated insulation voltage Ui: up to 1000V AC - 1500V DC; Rated peak short-circuit current Ipk: up to 330kA; Rated service voltage Ue: up to 1000V AC - 1500V DC; Rated short-time withstand current Icw: up to 150kA; Seismic withstand capability test: In accordance with Standard IEE Std 693; Vibration test: In accordance with Standard IEC 60068-2-57; Voltage: 400 V
Type - Electrical - Loads - Connection Voltage: 400 V
Type - Identity Data - Article Description: System pro E power 2x Top Busbar System switchboard + Corner Structure; Article Type: 2000x800x500+2000x800x500; Base Family Version: 12.12; Category: EL_PANEL; Content Supplier URL: www.MEPcontent.com; Copyright: © Stabiplan International BV; Custom: no; Description: System pro E power 2x Top Busbar System switchboard + Corner Structure; EMCS Version: 4.0; ETIM Article Class: EC000261; Family Version: 12.12; Manufacturer: ABB; Manufacturer URL: http://new.abb.com/low-voltage/products/system-pro-e/system-pro-e-power/system-pro-e-power; MEPcontent Class: DISTRIBUTION_PANEL; Model: 2000x800x500+2000x800x500; OmniClass Number: 23.80.30.11.17; OmniClass Title: Distribution Boards and Control Panels; Product Line: ABB; Revit Version: 2017; Type Name: 2000x800x500+2000x800x500; URL: www.stabiplan.com; Watermarked By: www.stabiplan.com
Type - Materials and Finishes - Black: Color RGB 028-028-028; Cabinet: Color RGB 215-215-215; Grey: Color RGB 082-090-097; Light Grey: Color RGB 180-180-180
Type - Other - Category: Electrical Equipment; Anti-Seismic Plinth Thickness: 100 mm; Corner Structure: 500x500; Corner Structure Height: yes; Door Opening 135°: no; Family Name: E_Distribution Panel_MEPcontent_ABB_System Pro E Power Top Busbar System_with Corner Structure_INT-EN; FP1 Blind Door IP40/41: Blind Door IP40/41; FP1 Blind Door IP65: Blind Door IP65; FP1 Blind Top Arc Fault Resistant: Blind Top Arc Fault Resistant; FP1 Bottom Blind IP30/65: Bottom Blind IP30/65; FP1 Bottom Internal Bottom IP40: Bottom Internal Bottom IP40; FP1 Bottom Open IP65: Bottom Open IP65; FP1 Closing Profile IP30/31: Closing Profile IP30/31; FP1 Glass Door IP40/41: Glass Door IP40/41; FP1 Glass Door IP65: Glass Door IP65; FP1 Rear Panel Blind IP30/65: Rear Panel Blind IP30/65; FP1 Rear Panel Vented IP30/41: Rear Panel Vented IP30/41; FP1 Side Panels Blind IP30/65: Side Panels Blind IP30/65; FP1 Side Panels Vented IP30/41: Side Panels Vented IP30/41; FP1 Top Blind IP30/65: Top Blind IP30/65; FP1 Top Open IP65: Top Open IP65; FP2 Closing Profile IP30/31: Closing Profile IP30/31; Lifting Reinforcements Right: no; Lookup Table: Parameters_ABB Pro E Power_External Dimensions; Service Area Width 1: 449.5 mm; Type Number: 3
Type - Visibility - Anti-Seismic Plinth: no; Anti-Seismic Plinth Length 1: 399 mm; Anti-Seismic Plinth Length 2: 399 mm; Anti-Seismic Plinth Right 1: no; Anti-Seismic Plinth Right 2: no; Anti-Seismic Plinth Right 2 Safe: no; Corner Structure: yes; Door Front Mounted: yes; Existing Anti-Seismic Plinth: no
Pset_ManufacturerTypeInformation - Manufacturer: ABB
Constraints - Offset: 0 mm
Dimensions - Area: 56.7204 m2; Internal Dimensions: 2000x800x500+2000x800x500; Volume: 1.9884 m3
Electrical - Circuiting - Electrical Data: Power - Unbalanced1 400 V/3-0 VA-Power - Unbalanced2 400 V/3-0 VA
Electrical - Loads - Apparent Load Phase A: 0 W; Apparent Load Phase B: 0 W; Apparent Load Phase C: 0 W; Load Classification: Other; Power: 0 W; Power L1: 0 W; Power L2: 0 W; Power L3: 0 W; Total Connected: 0 W; Total Demand Factor: 1; Total Estimated Demand: 0 W
General - Bottom Panel 1: Bottom Blind IP30/65; Bottom Panel 2: Bottom Blind IP30/65; Front Panel 1: Blind Door IP40/41; Front Panel 2: Blind Door IP40/41; Plinth Heigth: 120 mm; Rear Panel 1: Rear Panel Blind IP30/65; Rear Panel 2: Rear Panel Blind IP30/65; Side Panels 1: Side Panels Blind IP30/65; Side Panels 2: Side Panels Blind IP30/65; Top Panel 1: Top Blind IP30/65; Top Panel 2: Top Blind IP30/65
Identity Data - Design Option: Main Model; Function Code: E6211; Mark: 2
Other - Angle Ring Safe: 45 deg; Angle Ring Safe 1: 45 deg; Angle Ring Safe 2: 180 deg; Antiseismic Plinth Left: yes; Antiseismic Plinth Left Length Safe: 899 mm; Antiseismic Plinth Left Length Safe 2: 899 mm; Antiseismic Plinth Length Safe 1: 899 mm; Antiseismic Plinth Length Safe 2: 899 mm; Anti-Seismic Plinth Right Length Safe: 899 mm; Back Plate 1 Visible: no; Back Plate 2 Visible: yes; Corner Position Safe: 1498 mm; Corner Structure Angle: 180 deg; Corner Structure Left: yes; Corner Structure Offset Left: 899 mm; Corner Structure Offset Right: 899 mm; Corner Structure Right Safe: no; Door Back Mounted: no; Door Side: yes; Eyebolts For Lifting Condition: 889 mm; Eyebolts For Lifting Condition 2: 10 mm; Eyebolts For Lifting Left: yes; Eyebolts For Lifting Right: no; Family: E_Distribution Panel_MEPcontent_ABB_System Pro E Power Top Busbar System_with Corner Structure_INT-EN: 2000x800x500+2000x800x500; Family and Type: E_Distribution Panel_MEPcontent_ABB_System Pro E Power Top Busbar System_with Corner Structure_INT-EN: 2000x800x500+2000x800x500; FP Blind Door IP40/41: yes; FP Blind Door IP65: no; FP Blind Top Arc Fault Resistant: no; FP Bottom Blind IP30/65: yes; FP Bottom Internal Bottom IP40: no; FP Bottom Open IP65: no; FP Closing Profile IP30/31: no; FP Glass Door IP40/41: no; FP Glass Door IP65: no; FP Rear Panel Blind IP30/65: yes; FP Rear Panel Vented IP30/41: no; FP Side Panels Blind IP30/65: yes; FP Side Panels Vented IP30/41: no; FP Top Blind IP30/65: yes; FP Top Open IP65: no; Front Panel Angle: 90 deg; Half Depth: 299.5 mm; Half Depth Safe: 289.5 mm; Lifting Reinforcements Condition: 0 mm; Lifting Reinforcements Condition 2: 889 mm; Lifting Reinforcements Left: yes; Plinth 100mm: yes; Plinth Geometry Safe: 0 mm; Service Area Depth: 899 mm; Service Area Width 2: 449.5 mm; Show Service Area Safe 1: no; Show Service Area Safe 2: no; Type: E_Distribution Panel_MEPcontent_ABB_System Pro E Power Top Busbar System_with Corner Structure_INT-EN: 2000x800x500+2000x800x500; Type Id: E_Distribution Panel_MEPcontent_ABB_System Pro E Power Top Busbar System_with Corner Structure_INT-EN: 2000x800x500+2000x800x500; Wall-Mounting Brackets Back: no; Wall-Mounting Brackets Front: no
Phasing - Phase Created: 3. New Construction
Visibility - Corner Structure Right: no; Door Opening 45°: no; Door Opening 90°: yes; Eyebolts For Lifting: no; Lifting Reinforcements: no; Plinth 100 mm: yes; Plinth 200 mm: no; Show Service Area: no; Wall-Mounting Brackets 1: no; Wall-Mounting Brackets 2: no
